# IAR project 12S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Source_Code\Drivers\V85XX_Driver\src; ..\Source_Code\Drivers\V85XX_Driver\inc; ..\Source_Code\Drivers\MCAL\V94XX\inc; ..\Source_Code\Drivers\MCAL\V94XX\src; ..\Source_Code\Drivers\Service_Layer\inc; ..\Source_Code\Drivers\Service_Layer\src; ..\Source_Code\Drivers\CMSIS\Include; ..\Source_Code\Drivers\Meter\src; ..\Source_Code\Drivers\Meter\inc; cmsis; ..\Source_Code\Config; ..\Source_Code\Services\SW_Timer; ..\Source_Code\Services; ..\Source_Code\File_System\EEPROM; ..\Source_Code\File_System\App; ..\Source_Code\Main; ..\Source_Code\Control; ..\Source_Code\Control\Disconnector\Inc; ..\Source_Code\Tarriff_Payment; ..\Source_Code\Tarriff_Payment\Seasonal_Tarrif; ..\Source_Code\Self_Test; ..\Source_Code\Metering\V9203; ..\Source_Code\Metering\V9360; ..\Source_Code\Metering\V9381; ..\Source_Code\Metering\V9261f; ..\Source_Code\Metering\App; ..\Source_Code\Metering\ADE7953; ..\Source_Code\Metering\Limiter\Inc; ..\Source_Code\Metering\Limiter; ..\Source_Code\Metering\PowerQuality; ..\Source_Code\Metering\Tarrif_Registers; ..\Source_Code\Metering\Two_Phase; ..\Source_Code\Communication\App; ..\Source_Code\Services; ..\Source_Code\Power_modes; ..\Source_Code\Display; ..\Source_Code\Display\App; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Communication\GPRS; ..\Source_Code\Communication\GPRS\App; ..\Source_Code\Communication\GPRS\Modem; ..\Source_Code\Communication\Bluetooth; ..\Source_Code\Communication\Ymodem; ..\Source_Code\Communication\RF_Link\App; ..\Source_Code\Communication\RF_Link\TI_CC1120; ..\Source_Code\Communication\IEC62056-21; ..\Source_Code\Communication\RFID\APP; ..\Source_Code\Communication\RFID\MFRC522; ..\Source_Code\Communication\AES_Protocol; ..\Source_Code\Communication\Dlms; ..\Source_Code\Communication\Dlms\Profile; ..\Source_Code\Communication\Dlms\Cal; ..\Source_Code\Communication\Dlms\Cal\Src; ..\Source_Code\Communication\Dlms\Cosem; ..\Source_Code\Communication\Dlms\Cosem\Inc; ..\Source_Code\Communication\Dlms\Cosem\Src; ..\Source_Code\Communication\Dlms\Dal; ..\Source_Code\Communication\Dlms\LoadLimitPlan; ..\Source_Code\Communication\Dlms\Dal\Src; ..\Source_Code\Communication\Dlms\Dlms; ..\Source_Code\Communication\Dlms\Dlms\Inc; ..\Source_Code\Communication\Dlms\Dlms\Src; ..\Source_Code\Communication\Dlms\Os; ..\Source_Code\Communication\Dlms\Os\Src; ..\Source_Code\Communication\Dlms\Events; ..\Source_Code\Communication\Dlms\Events\EventLog; ..\Source_Code\Communication\STS; ..\Source_Code\Communication\RF_Link\CC1120; ..\Source_Code\Config; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Display\dot_matrix_LCD; ..\Source_Code\KeyPad; ..\Source_Code\Services\Soft_Spi_Intf\SOFT_SPI_DRV; ..\Source_Code\Services\Soft_Spi_Intf; ..\Source_Code\File_System\Flash; ..\Source_Code\Group_Metering\inc; ..\Source_Code\Communication\DeltaAlgorithm; ..\Source_Code\Communication\ContactCard; ..\Source_Code\Drivers\CMSIS_Driver\Inc; ..\Source_Code\Drivers\CMSIS_Driver\Src; ..\Source_Code\Drivers\CMSIS_Driver\Config; ..\Source_Code\Drivers\Device\Include; ..\Source_Code\Drivers\MCAL\V85XX\src; ..\Source_Code\Drivers\MCAL\V85XX\inc; ..\Source_Code\Drivers\MCAL\V94XX\src; ..\Source_Code\Drivers\MCAL\V94XX\inc; ..\Source_Code\Drivers\Service_Layer\inc; ..\Source_Code\Drivers\Service_Layer\src; ..\Source_Code\Drivers\MCAL\Common_Drivers\inc; ..\Source_Code\Communication\G2_Data_Model; ..\Source_Code\Communication\UI
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 12S.hex
  ILINK.IlinkOutputFile: 12S.out
  ILINK.IlinkIcfFile: V85XX_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Source_Code\Drivers\V85XX_Driver\src; ..\Source_Code\Drivers\V85XX_Driver\inc; ..\Source_Code\Drivers\CMSIS\Device; ..\Source_Code\Drivers\CMSIS\Include; ..\Source_Code\Drivers\Meter\src; ..\Source_Code\Drivers\Meter\inc; cmsis; ..\Source_Code\Config; ..\Source_Code\Services\SW_Timer; ..\Source_Code\Services; ..\Source_Code\File_System\EEPROM; ..\Source_Code\File_System\App; ..\Source_Code\Main; ..\Source_Code\Control; ..\Source_Code\Control\Disconnector\Inc; ..\Source_Code\Tarriff_Payment; ..\Source_Code\Self_Test; ..\Source_Code\Metering\V9203; ..\Source_Code\Metering\V9261f; ..\Source_Code\Metering\App; ..\Source_Code\Metering\ADE7953; ..\Source_Code\Metering\Limiter\Inc; ..\Source_Code\Communication\App; ..\Source_Code\Services; ..\Source_Code\Power_modes; ..\Source_Code\Display; ..\Source_Code\Display\App; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Communication\GPRS; ..\Source_Code\Communication\GPRS\App; ..\Source_Code\Communication\GPRS\Modem; ..\Source_Code\Communication\Bluetooth; ..\Source_Code\Communication\RF_Link\App; ..\Source_Code\Communication\RF_Link\TI_CC1120; ..\Source_Code\Communication\IEC62056-21; ..\Source_Code\Communication\RFID\APP; ..\Source_Code\Communication\RFID\MFRC522; ..\Source_Code\Communication\AES_Protocol; ..\Source_Code\Communication\Dlms; ..\Source_Code\Communication\Dlms\Cal; ..\Source_Code\Communication\Dlms\Cal\Src; ..\Source_Code\Communication\Dlms\Cosem; ..\Source_Code\Communication\Dlms\Cosem\Inc; ..\Source_Code\Communication\Dlms\Cosem\Src; ..\Source_Code\Communication\Dlms\Dal; ..\Source_Code\Communication\Dlms\Dal\Src; ..\Source_Code\Communication\Dlms\Dlms; ..\Source_Code\Communication\Dlms\Dlms\Inc; ..\Source_Code\Communication\Dlms\Dlms\Src; ..\Source_Code\Communication\Dlms\Os; ..\Source_Code\Communication\Dlms\Os\Src; ..\Source_Code\Config; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\KeyPad; ..\Source_Code\Services\Soft_Spi_Intf\SOFT_SPI_DRV; ..\Source_Code\Services\Soft_Spi_Intf; ..\Source_Code\File_System\Flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 12S.srec
  group (top)
    ./: 12S.eww startup_V85XX.s
  group Communication/AES_Protocol
    ../Source_Code/Communication/AES_Protocol/: AES.c AES.h gcm.c gcm.h
  group Communication/App
    ../Source_Code/Communication/App/: comm.c comm.h
  group Communication/Bluetooth
    ../Source_Code/Communication/Bluetooth/: Bluetooth_cc41.c Bluetooth_cc41.h
  group Communication/CONSOL
    ../Source_Code/Communication/CONSOL/: Consol_Config.h Consol_Interface.h Consol_program.c
  group Communication/ContactCard
    ../Source_Code/Communication/ContactCard/: contact_card.c contact_card.h iso7816_3_ctrl.c iso7816_3_ctrl.h iso7816_4.c iso7816_4.h
  group Communication/DeltaAlgorithm
    ../Source_Code/Communication/DeltaAlgorithm/: Delta_Algorithm.c Delta_Algorithm.h
  group Communication/Dlms
    ../Source_Code/Communication/Dlms/: Clock.c Clock.h pc_plat.c pc_plat.h
  group Communication/Dlms/Cal
    ../Source_Code/Communication/Dlms/Cal/: Cal_Itf.h
  group Communication/Dlms/Cal/Src
    ../Source_Code/Communication/Dlms/Cal/Src/: Cal_Act.c Cal_Evt.c Cal_Get.c Cal_Obj.c Cal_Set.c
  group Communication/Dlms/Cosem
    ../Source_Code/Communication/Dlms/Cosem/: Cosem_Itf.h
  group Communication/Dlms/Cosem/Inc
    ../Source_Code/Communication/Dlms/Cosem/Inc/: Cosem_Inc.h
  group Communication/Dlms/Cosem/Src
    ../Source_Code/Communication/Dlms/Cosem/Src/: Cosem_Main.c
  group Communication/Dlms/Dal
    ../Source_Code/Communication/Dlms/Dal/: Dal_Itf.h
  group Communication/Dlms/Dal/Src
    ../Source_Code/Communication/Dlms/Dal/Src/: Dal_E2p.c Dal_Ip.c Dal_Phy.c Dal_Rs.c Dal_Sys.c
  group Communication/Dlms/Dlms
    ../Source_Code/Communication/Dlms/Dlms/: Dlms_Itf.h
  group Communication/Dlms/Dlms/Inc
    ../Source_Code/Communication/Dlms/Dlms/Inc/: Channels.h Dlms_Appli.h Dlms_Asso.h Dlms_Gcm.h Dlms_Hdlc.h Dlms_Hdlc_plat.h Dlms_Inc.h Dlms_Intf.h Dlms_IpWrap.h Dlms_PhyLp.h Dlms_PhyRs.h Dlms_Secur.h Dlms_str_tools.h Dlms_Switch.h Dlms_Switchdl.h Dlms_SwitchPhy.h Dlms_Xdr.h plat.h TIMER_hdlc.h
  group Communication/Dlms/Dlms/Src
    ../Source_Code/Communication/Dlms/Dlms/Src/: Channels.c Channels_plat.c Dlms_Appli.c Dlms_Asso.c Dlms_Gcm.c Dlms_Hdlc.c Dlms_Hdlc_plat.c Dlms_Intf.c Dlms_IpWrap.c Dlms_Main.c Dlms_PhyLp.c Dlms_PhyRs.c Dlms_Secur.c Dlms_str_tools.c Dlms_Switch.c Dlms_SwitchDl.c Dlms_SwitchPhy.c Dlms_Xdr.c plat.c TIMER_hdlc.c
  group Communication/Dlms/Events
    ../Source_Code/Communication/Dlms/Events/: Event_Notification.c Event_Notification.h
  group Communication/Dlms/Events/EventLog
    ../Source_Code/Communication/Dlms/Events/EventLog/: COC_EventLog_Config.h Event_Log.c Event_Log.h Tampers.c Tampers.h
  group Communication/Dlms/LoadLimitPlan
    ../Source_Code/Communication/Dlms/LoadLimitPlan/: Load_Limit_Plan.c Load_Limit_Plan.h
  group Communication/Dlms/Os/Src
    ../Source_Code/Communication/Dlms/Os/Src/: Os_Error.c
  group Communication/Dlms/Profile
    ../Source_Code/Communication/Dlms/Profile/: Profile.c Profile.h
  group Communication/G2_Data_Model
    ../Source_Code/Communication/G2_Data_Model/: G2_DM.c G2_DM.h
  group Communication/GPRS/App
    ../Source_Code/Communication/GPRS/App/: gprs_sys.c gprs_sys.h
  group Communication/GPRS/Modem
    ../Source_Code/Communication/GPRS/Modem/: MODEM.c MODEM.h
  group Communication/IEC62056-21
    ../Source_Code/Communication/IEC62056-21/: iec62056_21_slave.c iec62056_21_slave.h
  group Communication/RF_Link/App
    ../Source_Code/Communication/RF_Link/App/: RF_Link.c RF_Link.h
  group Communication/RF_Link/CC1120
    ../Source_Code/Communication/RF_Link/CC1120/: cc1120_interface.c cc1120_interface.h cc1120_MAC.c cc1120_MAC.h cc1120_RF.c cc1120_RF.h
  group Communication/RF_Link/TI_CC1120
    ../Source_Code/Communication/RF_Link/TI_CC1120/: TI_CC1120.c TI_CC1120.h
  group Communication/RFID/APP
    ../Source_Code/Communication/RFID/App/: rfid_sys.c rfid_sys.h
  group Communication/RFID/MFRC522
    ../Source_Code/Communication/RFID/MFRC522/: MFRC522.c MFRC522.h
  group Communication/STS
    ../Source_Code/Communication/STS/: bit.c bit.h queue.c queue.h STS_Common.c STS_Common.h STS_CRC.c STS_CRC.h STS_Decrypt.c STS_Decrypt.h STS_def.h STS_DES.c STS_DES.h STS_Execute.c STS_execute.h STS_Key_Store.c STS_Key_Store.h STS_Module.c STS_Module.h STS_test.c STS_test.h STS_Timer.c STS_Timer.h STS_Token_Interface.c STS_Token_Interface.h STS_Token_Store.c STS_Token_Store.h STS_Types.h
  group Communication/UI
    ../Source_Code/Communication/UI/: UI.c UI.h
  group Communication/Ymodem
    ../Source_Code/Communication/Ymodem/: ymodem.c ymodem.h
  group Config
    ../Source_Code/Config/: config.h
  group Control
    ../Source_Code/Control/: ctrl.c ctrl.h
  group Control/Disconnector/Inc
    ../Source_Code/Control/Disconnector/Inc/: disconnector.h
  group Control/Disconnector/Src
    ../Source_Code/Control/Disconnector/Src/: disconnector.c
  group Display/App
    ../Source_Code/Display/App/: display.c display.h display_cfg.h
  group Display/dot_matrix_LCD
    ../Source_Code/Display/dot_matrix_LCD/: Dot_Matrix_Commands.h Dot_Matrix_Interfacing.c Dot_Matrix_Interfacing.h Dot_Matrix_MCAL.c Dot_Matrix_MCAL.h
  group Display/lcd_HQ30774
    ../Source_Code/Display/lcd_HQ30774/: LCD_HQ30774.c LCD_HQ30774.h lcd_HQ30774_cfg.h Vango85x_lcd.c Vango85x_lcd.h
  group Drivers/MCAL/Common_Drivers/inc
    ../Source_Code/Drivers/MCAL/Common_Drivers/inc/: Driver_Common.h Driver_ISO7816.h type_def.h
  group Drivers/MCAL/V85XX/inc
    ../Source_Code/Drivers/MCAL/V85XX/inc/: v85xx.h v85xx_adc.h v85xx_adc_tiny.h v85xx_ana.h v85xx_clk.h v85xx_CodeRAM.h v85xx_comp.h v85xx_cortex.h v85xx_crypt.h v85xx_dma.h v85xx_flash.h v85xx_gpio.h v85xx_i2c.h v85xx_iso7816.h v85xx_isr.h v85xx_lcd.h v85xx_LoadNVR.h v85xx_misc.h v85xx_pmu.h v85xx_pwm.h v85xx_rtc.h v85xx_spi.h v85xx_tmr.h v85xx_u32k.h v85xx_uart.h v85xx_version.h v85xx_wdt.h
  group Drivers/MCAL/V85XX/src
    ../Source_Code/Drivers/MCAL/V85XX/src/: Driver_ISO7816_V85XX.c v85xx_adc.c v85xx_adc_tiny.c v85xx_ana.c v85xx_clk.c v85xx_comp.c v85xx_cortex.c v85xx_crypt.c v85xx_dma.c v85xx_flash.c v85xx_gpio.c v85xx_i2c.c v85xx_iso7816.c v85xx_isr.c v85xx_lcd.c v85xx_LoadNVR.c v85xx_misc.c v85xx_pmu.c v85xx_pwm.c v85xx_rtc.c v85xx_spi.c v85xx_tmr.c v85xx_u32k.c v85xx_uart.c v85xx_version.c v85xx_wdt.c
  group Drivers/MCAL/V94XX/inc
    ../Source_Code/Drivers/MCAL/V94XX/inc/: System_V94XX.h V94XX.h V94XX_ADC.h V94XX_ADC_Tiny.h V94XX_ANA.h V94XX_CLK.h V94XX_CodeRAM.h V94XX_COMP.h V94XX_CORTEX.h V94XX_CRYPT.h V94XX_DMA.h V94XX_EnergyMetering.h V94XX_FLASH.h V94XX_GPIO.h V94XX_I2C.h V94XX_ISO7816.h V94XX_ISR.h V94XX_LCD.h V94XX_LoadNVR.h V94XX_MISC.h V94XX_PMU.h V94XX_PWM.h V94XX_RTC.h V94XX_SPI.h V94XX_TMR.h V94XX_U32K.h V94XX_UART.h V94XX_Version.h V94XX_WDT.h
  group Drivers/MCAL/V94XX/src
    ../Source_Code/Drivers/MCAL/V94XX/src/: Driver_ISO7816_V94XX.c System_V94XX.c V94XX_ADC.c V94XX_ADC_Tiny.c V94XX_ANA.c V94XX_CLK.c V94XX_CodeRAM.c V94XX_COMP.c V94XX_CORTEX.c V94XX_CRYPT.c V94XX_DMA.c V94XX_FLASH.c V94XX_GPIO.c V94XX_I2C.c V94XX_ISO7816.c V94XX_ISR.c V94XX_LCD.c V94XX_LoadNVR.c V94XX_MISC.c V94XX_PMU.c V94XX_PWM.c V94XX_RTC.c V94XX_SPI.c V94XX_TMR.c V94XX_U32K.c V94XX_UART.c V94XX_Version.c V94XX_WDT.c
  group Drivers/Service_Layer/inc
    ../Source_Code/Drivers/Service_Layer/inc/: ADC_Config.h ADC_Interface.h CLK_Config.h CLK_Interface.h GPIO_Config.h GPIO_Interface.h I2C_Config.h I2C_Interface.h ISO7816_Config.h ISO7816_Interface.h RTC_Config.h RTC_Interface.h SPI_Config.h SPI_Interface.h SystemTick_Config.h SystemTick_Interface.h Timer_Config.h Timer_Interface.h UART_Config.h UART_Interface.h
  group Drivers/Service_Layer/src
    ../Source_Code/Drivers/Service_Layer/src/: ADC_Program.c CLK_Program.c GPIO_Program.c I2C_Program.c ISO7816_Program.c RTC_Program.c SPI_Program.c SystemTick_Program.c Timer_Program.c UART_Program.c
  group File_System/App
    ../Source_Code/File_System/App/: file_sys.c file_sys.h
  group File_System/EEPROM
    ../Source_Code/File_System/EEPROM/: EEPROM.c EEPROM.h EEPROM_Addresses.h
  group File_System/Flash
    ../Source_Code/File_System/Flash/: Flash.c Flash.h FLASH_Addresses.h Flash_app.c Flash_app.h
  group Group_Metering/inc
    ../Source_Code/Group_Metering/inc/: GM_Config.h GM_Data_Model.h GM_File_Sys_Manager.h GM_GPRS_Interface.h GM_Manager.h iec62056_21_master.h
  group Group_Metering/src
    ../Source_Code/Group_Metering/src/: GM_Data_Model.c GM_File_Sys_Manager.c GM_GPRS_Interface.c GM_Manager.c iec62056_21_master.c
  group KeyPad
    ../Source_Code/KeyPad/: Keypad.c keypad.h
  group Main
    ../Source_Code/Main/: Main.c meter_init.c meter_init.h Task_priority.c task_priority.h
  group Metering/ADE7953
    ../Source_Code/Metering/ADE7953/: ADE7953.c ADE7953.h ADE7953_cfg.h
  group Metering/App
    ../Source_Code/Metering/App/: Meter_Config.h Meter_Interface.h Meter_Program.c
  group Metering/Limiter
    ../Source_Code/Metering/Limiter/: Limiter_new.c Limiter_new.h
  group Metering/Limiter/Inc
    ../Source_Code/Metering/Limiter/Inc/: limiter.h
  group Metering/Limiter/Src
    ../Source_Code/Metering/Limiter/Src/: limiter.c
  group Metering/PowerQuality
    ../Source_Code/Metering/PowerQuality/: Power_Quality.c Power_Quality.h
  group Metering/Tarrif_Registers
    ../Source_Code/Metering/Tarrif_Registers/: TarrifRegisters.c TarrifRegisters.h
  group Metering/V9203
    ../Source_Code/Metering/V9203/: V9203.c V9203.h V9203_cfg.h
  group Metering/V9261f
    ../Source_Code/Metering/V9261f/: V9261f.c V9261f.h V9261f_cfg.h
  group Metering/V9360
    ../Source_Code/Metering/V9360/: V9360.c V9360.h
  group Metering/V9381
    ../Source_Code/Metering/V9381/: V9381.c V9381.h
  group Power_modes
    ../Source_Code/Power_modes/: Power_modes.c Power_modes.h
  group Self_Test
    ../Source_Code/Self_Test/: self_test.c Self_test.h
  group Self_Test/Services
    ../Source_Code/Services/: basic_srv.c basic_srv.h
  group Self_Test/Services/Soft_Spi_Intf
    ../Source_Code/Services/Soft_Spi_Intf/: soft_spi_intf.c soft_spi_intf.h
  group Self_Test/Services/Soft_Spi_Intf/SOFT_SPI_DRV
    ../Source_Code/Services/Soft_Spi_Intf/SOFT_SPI_DRV/: soft_spi_drv.c soft_spi_drv.h
  group Self_Test/Services/SW_Timer
    ../Source_Code/Services/SW_Timer/: OS_Itf.h Os_Timer.c
  group Tarrif_Payment
    ../Source_Code/Tarriff_Payment/: trf_pymt.c trf_pymt.h
  group Tarrif_Payment/Seasonal_Tarrif
    ../Source_Code/Tarriff_Payment/Seasonal_Tarrif/: Activity_Calender.c Activity_Calender.h Calender_Manager.c Calender_Manager.h Register_Activation.c Register_Activation.h Special_Days.c Special_Days.h Tariff_Script_Table.c Tariff_Script_Table.h
