<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\12S.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\V94XX.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\V94XXA.ewp</path>
    </project>
    <batchBuild />
</workspace>
