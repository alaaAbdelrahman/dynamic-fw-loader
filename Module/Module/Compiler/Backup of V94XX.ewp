# IAR project Backup of V94XX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V94XX VANGO V94XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\Source_Code\Drivers\MCAL\V94XX\inc; ..\Source_Code\Drivers\Service_Layer\inc; cmsis; ..\Source_Code\Config; ..\Source_Code\Services\SW_Timer; ..\Source_Code\Services; ..\Source_Code\File_System\EEPROM; ..\Source_Code\File_System\App; ..\Source_Code\Main; ..\Source_Code\Control; ..\Source_Code\Control\Disconnector\Inc; ..\Source_Code\Tarriff_Payment; ..\Source_Code\Tarriff_Payment\Seasonal_Tarrif; ..\Source_Code\Self_Test; ..\Source_Code\Metering\V9203; ..\Source_Code\Metering\V9360; ..\Source_Code\Metering\V9381; ..\Source_Code\Metering\V9261f; ..\Source_Code\Metering\App; ..\Source_Code\Metering\ADE7953; ..\Source_Code\Metering\Limiter\Inc; ..\Source_Code\Metering\Limiter; ..\Source_Code\Metering\PowerQuality; ..\Source_Code\Metering\Tarrif_Registers; ..\Source_Code\Metering\Two_Phase; ..\Source_Code\Metering\DIN_RAIL; ..\Source_Code\Metering\V9340; ..\Source_Code\Metering\V9240; ..\Source_Code\Communication\App; ..\Source_Code\Communication\RF_Link\CC1120; ..\Source_Code\Services; ..\Source_Code\Power_modes; ..\Source_Code\Display\App; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Communication\GPRS\App; ..\Source_Code\Communication\GPRS\Modem; ..\Source_Code\Communication\Bluetooth; ..\Source_Code\Communication\Ymodem; ..\Source_Code\Communication\RF_Link\App; ..\Source_Code\Communication\RF_Link\TI_CC1120; ..\Source_Code\Communication\IEC62056-21; ..\Source_Code\Communication\RFID\APP; ..\Source_Code\Communication\RFID\MFRC522; ..\Source_Code\Communication\AES_Protocol; ..\Source_Code\Communication\Dlms; ..\Source_Code\Communication\Dlms\Profile; ..\Source_Code\Communication\Dlms\Cal; ..\Source_Code\Communication\Dlms\Cosem; ..\Source_Code\Communication\Dlms\Cosem\Inc; ..\Source_Code\Communication\Dlms\Dal; ..\Source_Code\Communication\Dlms\LoadLimitPlan; ..\Source_Code\Communication\Dlms\Dlms; ..\Source_Code\Communication\Dlms\Dlms\Inc; ..\Source_Code\Communication\Dlms\Os; ..\Source_Code\Communication\Dlms\Events; ..\Source_Code\Communication\Dlms\Events\EventLog; ..\Source_Code\Communication\STS; ..\Source_Code\Config; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Display\dot_matrix_LCD; ..\Source_Code\KeyPad; ..\Source_Code\Services\Soft_Spi_Intf\SOFT_SPI_DRV; ..\Source_Code\Services\Soft_Spi_Intf; ..\Source_Code\File_System\Flash; ..\Source_Code\Communication\DeltaAlgorithm; ..\Source_Code\Communication\ContactCard; ..\Source_Code\Drivers\MCAL\V85XX\inc; ..\Source_Code\Drivers\MCAL\V94XX\src; ..\Source_Code\Drivers\MCAL\V94XX\inc; ..\Source_Code\Drivers\Service_Layer\inc; ..\Source_Code\Drivers\Service_Layer\src; ..\Source_Code\Drivers\MCAL\Common_Drivers\inc; ..\Source_Code\Communication\Cyshield_G2; ..\Source_Code\Communication\AES_CBC_ECB; ..\Source_Code\Communication\CMAC; ..\Source_Code\Communication\ECDSA; ..\Source_Code\Communication\G2_Data_Model; ..\Source_Code\Communication\UI; ..\Source_Code\Communication\HW_CRYPT; ..\Source_Code\Group_Metering\inc; ..\Source_Code\Communication\PLC\app\extern\flash\inc; ..\Source_Code\Communication\PLC\app\extern\ipv6\inc; ..\Source_Code\Communication\PLC\app\inc; ..\Source_Code\Communication\PLC\bsp\rx\api\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\g3\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\g3\src; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\sys\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\sys\src; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\src\core; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\src\if; ..\Source_Code\Communication\PLC\cpx3_api\fw_download\inc; ..\Source_Code\Communication\PLC\cpx3_api\util\inc; ..\Source_Code\Communication\PLC\cpx3_fw; ..\Source_Code\Communication\PLC\extern\checksum\inc; ..\Source_Code\Communication\PLC\extern\common\inc; ..\Source_Code\Communication\PLC\extern\crc\inc; ..\Source_Code\Communication\PLC\extern\crc\src; ..\Source_Code\Communication\PLC\extern\led\inc; ..\Source_Code\Communication\PLC\extern\memory\inc; ..\Source_Code\Communication\PLC\extern\queue\inc; ..\Source_Code\Communication\PLC\extern\stdio\inc; ..\Source_Code\Communication\PLC\extern\timer\inc; ..\Source_Code\Communication\CONSOL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Source_Code\Communication\PLC\app\extern\flash\inc; ..\Source_Code\Communication\PLC\app\extern\ipv6\inc; ..\Source_Code\Communication\PLC\app\inc; ..\Source_Code\Communication\PLC\bsp\rx\api\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\g3\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\g3\src; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\sys\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\sys\src; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\inc; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\src\core; ..\Source_Code\Communication\PLC\cpx3_api\cpx3_sap\uif\src\if; ..\Source_Code\Communication\PLC\cpx3_api\fw_download\inc; ..\Source_Code\Communication\PLC\cpx3_api\util\inc; ..\Source_Code\Communication\PLC\cpx3_fw; ..\Source_Code\Communication\PLC\extern\checksum\inc; ..\Source_Code\Communication\PLC\extern\common\inc; ..\Source_Code\Communication\PLC\extern\crc\inc; ..\Source_Code\Communication\PLC\extern\crc\src; ..\Source_Code\Communication\PLC\extern\led\inc; ..\Source_Code\Communication\PLC\extern\memory\inc; ..\Source_Code\Communication\PLC\extern\queue\inc; ..\Source_Code\Communication\PLC\extern\stdio\inc; ..\Source_Code\Communication\PLC\extern\timer\inc
  OBJCOPY.OOCOutputFile: V94XX.hex
  ILINK.IlinkOutputFile: V94XX.out
  ILINK.IlinkIcfFile: V94XX_flash.icf
  ILINK.IlinkAdditionalLibs: lib_energymetering.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Source_Code\Drivers\V85XX_Driver\src; ..\Source_Code\Drivers\V85XX_Driver\inc; ..\Source_Code\Drivers\CMSIS\Device; ..\Source_Code\Drivers\CMSIS\Include; ..\Source_Code\Drivers\Meter\src; ..\Source_Code\Drivers\Meter\inc; cmsis; ..\Source_Code\Config; ..\Source_Code\Services\SW_Timer; ..\Source_Code\Services; ..\Source_Code\File_System\EEPROM; ..\Source_Code\File_System\App; ..\Source_Code\Main; ..\Source_Code\Control; ..\Source_Code\Control\Disconnector\Inc; ..\Source_Code\Tarriff_Payment; ..\Source_Code\Self_Test; ..\Source_Code\Metering\V9203; ..\Source_Code\Metering\V9261f; ..\Source_Code\Metering\App; ..\Source_Code\Metering\ADE7953; ..\Source_Code\Metering\Limiter\Inc; ..\Source_Code\Communication\App; ..\Source_Code\Services; ..\Source_Code\Power_modes; ..\Source_Code\Display; ..\Source_Code\Display\App; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\Communication\GPRS; ..\Source_Code\Communication\GPRS\App; ..\Source_Code\Communication\GPRS\Modem; ..\Source_Code\Communication\Bluetooth; ..\Source_Code\Communication\RF_Link\App; ..\Source_Code\Communication\RF_Link\TI_CC1120; ..\Source_Code\Communication\IEC62056-21; ..\Source_Code\Communication\RFID\APP; ..\Source_Code\Communication\RFID\MFRC522; ..\Source_Code\Communication\AES_Protocol; ..\Source_Code\Communication\Dlms; ..\Source_Code\Communication\Dlms\Cal; ..\Source_Code\Communication\Dlms\Cal\Src; ..\Source_Code\Communication\Dlms\Cosem; ..\Source_Code\Communication\Dlms\Cosem\Inc; ..\Source_Code\Communication\Dlms\Cosem\Src; ..\Source_Code\Communication\Dlms\Dal; ..\Source_Code\Communication\Dlms\Dal\Src; ..\Source_Code\Communication\Dlms\Dlms; ..\Source_Code\Communication\Dlms\Dlms\Inc; ..\Source_Code\Communication\Dlms\Dlms\Src; ..\Source_Code\Communication\Dlms\Os; ..\Source_Code\Communication\Dlms\Os\Src; ..\Source_Code\Config; ..\Source_Code\Display\lcd_HQ30774; ..\Source_Code\KeyPad; ..\Source_Code\Services\Soft_Spi_Intf\SOFT_SPI_DRV; ..\Source_Code\Services\Soft_Spi_Intf; ..\Source_Code\File_System\Flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 12S.srec
  ILINK.IlinkOutputFile: 12S.out
  group (top)
    ./: 12S.eww startup_V94XX.s
  group Communication/PLC/app/extern/flash/src
    ../Source_Code/Communication/PLC/app/extern/flash/src/: r_demo_nvm_process.c r_demo_print.c r_flash_lib.c
  group Communication/PLC/app/extern/ipv6/src
    ../Source_Code/Communication/PLC/app/extern/ipv6/src/: r_check_sum.c r_icmp_v6.c r_ipv6_headers.c r_udp_headers.c
  group Communication/PLC/app/src
    ../Source_Code/Communication/PLC/app/src/: PLC_App.c r_demo_api.c r_demo_app.c r_demo_app_thread.c r_demo_bootstrap.c r_demo_common.c r_demo_config.c r_demo_eap.c r_demo_g3_cb.c r_demo_ib_access.c r_demo_main.c r_demo_metric_computation.c r_demo_os_wrapper.c r_demo_parameters.c r_demo_statistics.c r_demo_sys.c r_demo_sys_cb.c r_demo_tools.c
  group Communication/PLC/bsp/rx/api/src
    ../Source_Code/Communication/PLC/bsp/rx/api/src/: r_bsp_api.c
  group Communication/PLC/cpx3_api/cpx3_sap/g3/src
    ../Source_Code/Communication/PLC/cpx3_api/cpx3_sap/g3/src/: r_c3sap_adp.c r_c3sap_adp_convert.c r_c3sap_eap.c r_c3sap_eap_convert.c r_c3sap_g3.c r_c3sap_g3_depend.c r_c3sap_g3ctrl_convert.c r_c3sap_g3mac.c r_c3sap_g3mac_convert.c r_c3sap_g3rfmac.c r_c3sap_g3rfmac_convert.c
  group Communication/PLC/cpx3_api/cpx3_sap/sys/src
    ../Source_Code/Communication/PLC/cpx3_api/cpx3_sap/sys/src/: r_c3sap_sys.c r_c3sap_sys_convert.c r_c3sap_sys_depend.c r_c3sap_sys_thread.c
  group Communication/PLC/cpx3_api/cpx3_sap/uif/src/core
    ../Source_Code/Communication/PLC/cpx3_api/cpx3_sap/uif/src/core/: r_uif_buff_declared.c r_uif_data_manage.c r_uif_hdlc_process.c r_uif_intc.c r_uif_rx_process.c r_uif_tx_process.c
  group Communication/PLC/cpx3_api/cpx3_sap/uif/src/if
    ../Source_Code/Communication/PLC/cpx3_api/cpx3_sap/uif/src/if/: r_c3sap_uif.c r_c3sap_uif_drv.c
  group Communication/PLC/cpx3_api/fw_download/src
    ../Source_Code/Communication/PLC/cpx3_api/fw_download/src/: r_fw_download.c
  group Communication/PLC/cpx3_api/util/src
    ../Source_Code/Communication/PLC/cpx3_api/util/src/: r_cmn_param2text.c r_g3_param2text.c r_sys_param2text.c
  group Communication/PLC/cpx3_fw_new_v1
    ../Source_Code/Communication/PLC/cpx3_fw_new_v1/: CPX3_booting.c CPX3_booting.h cpx3_switch.c cpx3_switch.h
  group Communication/PLC/extern/checksum/src
    ../Source_Code/Communication/PLC/extern/checksum/src/: r_checksum.c
  group Communication/PLC/extern/common/src
    ../Source_Code/Communication/PLC/extern/common/src/: r_byte_swap.c r_io_vec.c r_mem_tools.c
  group Communication/PLC/extern/crc/src
    ../Source_Code/Communication/PLC/extern/crc/src/: r_crc32_api.c
  group Communication/PLC/extern/led/src
    ../Source_Code/Communication/PLC/extern/led/src/: r_led_api.c
  group Communication/PLC/extern/memory/src
    ../Source_Code/Communication/PLC/extern/memory/src/: r_memory_api.c
  group Communication/PLC/extern/queue/src
    ../Source_Code/Communication/PLC/extern/queue/src/: r_queue_api.c
  group Communication/PLC/extern/stdio/src
    ../Source_Code/Communication/PLC/extern/stdio/src/: r_stdio_api.c
  group Communication/PLC/extern/timer/src
    ../Source_Code/Communication/PLC/extern/timer/src/: r_app_timer.c
  group Config
    ../Source_Code/Config/: config.h
  group Drivers/MCAL/Common_Drivers/inc
    ../Source_Code/Drivers/MCAL/Common_Drivers/inc/: Driver_Common.h Driver_ISO7816.h type_def.h
  group Drivers/MCAL/V85XX/inc
    ../Source_Code/Drivers/MCAL/V85XX/inc/: v85xx.h v85xx_adc.h v85xx_adc_tiny.h v85xx_ana.h v85xx_clk.h v85xx_CodeRAM.h v85xx_comp.h v85xx_cortex.h v85xx_crypt.h v85xx_dma.h v85xx_flash.h v85xx_gpio.h v85xx_i2c.h v85xx_iso7816.h v85xx_isr.h v85xx_lcd.h v85xx_LoadNVR.h v85xx_misc.h v85xx_pmu.h v85xx_pwm.h v85xx_rtc.h v85xx_spi.h v85xx_tmr.h v85xx_u32k.h v85xx_uart.h v85xx_version.h v85xx_wdt.h
  group Drivers/MCAL/V85XX/src
    ../Source_Code/Drivers/MCAL/V85XX/src/: Driver_ISO7816_V85XX.c v85xx_adc.c v85xx_adc_tiny.c v85xx_ana.c v85xx_clk.c v85xx_comp.c v85xx_cortex.c v85xx_crypt.c v85xx_dma.c v85xx_flash.c v85xx_gpio.c v85xx_i2c.c v85xx_iso7816.c v85xx_isr.c v85xx_lcd.c v85xx_LoadNVR.c v85xx_misc.c v85xx_pmu.c v85xx_pwm.c v85xx_rtc.c v85xx_spi.c v85xx_tmr.c v85xx_u32k.c v85xx_uart.c v85xx_version.c v85xx_wdt.c
  group Drivers/MCAL/V94XX/inc
    ../Source_Code/Drivers/MCAL/V94XX/inc/: System_V94XX.h V94XX.h V94XX_ADC.h V94XX_ADC_Tiny.h V94XX_ANA.h V94XX_CLK.h V94XX_CodeRAM.h V94XX_COMP.h V94XX_CORTEX.h V94XX_CRYPT.h V94XX_DMA.h V94XX_EnergyMetering.h V94XX_FLASH.h V94XX_GPIO.h V94XX_I2C.h V94XX_ISO7816.h V94XX_ISR.h V94XX_LCD.h V94XX_LoadNVR.h V94XX_MISC.h V94XX_PMU.h V94XX_PWM.h V94XX_RTC.h V94XX_SPI.h V94XX_TMR.h V94XX_U32K.h V94XX_UART.h V94XX_Version.h V94XX_WDT.h
  group Drivers/MCAL/V94XX/src
    ../Source_Code/Drivers/MCAL/V94XX/src/: Driver_ISO7816_V94XX.c System_V94XX.c V94XX_ADC.c V94XX_ADC_Tiny.c V94XX_ANA.c V94XX_CLK.c V94XX_CodeRAM.c V94XX_COMP.c V94XX_CORTEX.c V94XX_CRYPT.c V94XX_DMA.c V94XX_FLASH.c V94XX_GPIO.c V94XX_I2C.c V94XX_ISO7816.c V94XX_ISR.c V94XX_LCD.c V94XX_LoadNVR.c V94XX_MISC.c V94XX_PMU.c V94XX_PWM.c V94XX_RTC.c V94XX_SPI.c V94XX_TMR.c V94XX_U32K.c V94XX_UART.c V94XX_Version.c V94XX_WDT.c
  group Drivers/Service_Layer/inc
    ../Source_Code/Drivers/Service_Layer/inc/: ADC_Config.h ADC_Interface.h CLK_Config.h CLK_Interface.h GPIO_Config.h GPIO_Interface.h I2C_Config.h I2C_Interface.h ISO7816_Config.h ISO7816_Interface.h RTC_Config.h RTC_Interface.h SPI_Config.h SPI_Interface.h SystemTick_Config.h SystemTick_Interface.h Timer_Config.h Timer_Interface.h UART_Config.h UART_Interface.h
  group Drivers/Service_Layer/src
    ../Source_Code/Drivers/Service_Layer/src/: ADC_Program.c CLK_Program.c GPIO_Program.c I2C_Program.c ISO7816_Program.c RTC_Program.c SPI_Program.c SystemTick_Program.c Timer_Program.c UART_Program.c
  group File_System/App
    ../Source_Code/File_System/App/: file_sys.c file_sys.h
  group File_System/EEPROM
    ../Source_Code/File_System/EEPROM/: EEPROM.c EEPROM.h EEPROM_Addresses.h
  group File_System/Flash
    ../Source_Code/File_System/Flash/: Flash.c Flash.h FLASH_Addresses.h Flash_app.c Flash_app.h
  group Main
    ../Source_Code/Main/: Main.c meter_init.c meter_init.h Task_priority.c task_priority.h
  group services
    ../Source_Code/Services/: basic_srv.c basic_srv.h
